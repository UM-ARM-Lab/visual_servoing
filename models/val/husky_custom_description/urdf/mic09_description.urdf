Commit message: change to model directory

File: models/val/husky_custom_description/urdf/mic09_description.urdf (robot description, URDF)
Before this commit: robot husky, 62 links, 61 joints
Joints:
- joint torso_to_cam: origin xyz=0 0 .44399 rpy=-1.570796 0 0 -> xyz=0 0 .44399 rpy=-1.9 0 0
